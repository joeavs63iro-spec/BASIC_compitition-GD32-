# Keil uVision project 01-speed_pid.uvprojx, settings and files
target GD32F30X_CL (6240000::V6.24::ARMCLANG)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\CODE;..\USER\inc;..\USER\src;..\..\Libraries\hefei_libraries;..\..\Libraries\hefei_peripheral;..\..\Libraries\Device\GD32F30x_standard_peripheral\Include;..\..\Libraries\Device\GD32F30x_standard_peripheral\Source;..\..\Libraries\Device\GD32F30x_standard_peripheral\Source\KEIL_StartAsm;..\..\Libraries\Device\GD32F30x_standard_peripheral\GD32F30x_Lib\Head;..\..\Libraries\Device\GD32F30x_standard_peripheral\GD32F30x_Lib\Inc;..\..\Libraries\Device\CMSIS;..\..\Libraries\Device\CMSIS\GD\GD32F30x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user_c
    ../USER/src/: gd32f30x_it.c main.c
  group user_h
    ../USER/inc/: gd32f30x_it.h main.h
  group startup
    ../../Libraries/Device/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../../Libraries/Device/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group doc
    ../../Libraries/doc/: readme.txt
  group hefei_libraries
    ../../Libraries/hefei_libraries/: headfile.h hf_adc.c hf_adc.h hf_exti.c hf_exti.h hf_flash.c hf_flash.h hf_gpio.c hf_gpio.h hf_i2c_hardware.c hf_i2c_hardware.h hf_i2c_software.c hf_i2c_software.h hf_pit.c hf_pit.h hf_pwm.c hf_pwm.h hf_qtimer.c hf_qtimer.h hf_spi.c hf_spi.h hf_systick.c hf_systick.h hf_uart.c hf_uart.h
  group hefei_peripheral
    ../../Libraries/hefei_peripheral/: HF_WS2812b.c HF_WS2812b.h HF_HC-SR04.c HF_HC-SR04.h HF_OLED.c HF_OLED.h HF_Double_DC_Motor.c HF_Double_DC_Motor.h dmx_tof400c.c dmx_tof400c.h
  group GD32F30x
    ../../Libraries/Device/GD32F30x_standard_peripheral/GD32F30x_Lib/Src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CODE
    ../CODE/: board.c board.h xunxian.c xunxian.h car_6keys.c car_6keys.h car_adc.c car_adc.h car_buzzer.c car_buzzer.h car_init.c car_init.h car_light.c car_light.h car_motion.c car_motion.h car_oled.c car_oled.h car_reed.c car_reed.h car_uart.c car_uart.h car_value_process.c car_value_process.h encoder.c encoder.h control.c control.h bluetooth_tuning.c bluetooth_tuning.h oledfont.h
target GD32F30X_XD (ARM-ADS)
  device: GD32F303RK GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000-0x2002FFFF)IROM(0x08000000-0x082FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
target GD32F30X_HD (6240000::V6.24::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\Libraries\Device\CMSIS;..\..\Libraries\Device\CMSIS\GD\GD32F30x\Include;..\CODE;..\USER\src;..\USER\inc;..\..\Libraries\hefei_libraries;..\..\Libraries\hefei_peripheral;..\..\Libraries\Device\CMSIS\GD\GD32F30x\Source\ARM;..\..\Libraries\Device\GD32F30x_standard_peripheral\GD32F30x_Lib\Inc;..\..\Libraries\Device\GD32F30x_standard_peripheral\GD32F30x_Lib\Head;..\..\Libraries\Device\GD32F30x_standard_peripheral\Include;..\..\Libraries\Device\GD32F30x_standard_peripheral\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
